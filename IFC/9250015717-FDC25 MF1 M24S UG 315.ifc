Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: d8c6b1a2-d763-488d-a09d-aa77247fa91e, NumberOfSaves: 37]
File name: Project Number
Time: 2024-02-23T13:28:30+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_2445567_1
Port_2445567_2

# IfcFlowController: NLRS_57_DUA_UN_round-firedamper-with-smokesensor-fdc25-ug_sacs:FDC25 MF1 M24S UG, NLRS_57_DUA_UN_round-firedamper-with-smokesensor-fdc25-ug_sacs:FDC25 MF1 M24S UG:2445567
In: Default
Type - Description: Ronde brandklep met rooksensor; PredefinedType: FIREDAMPER; Material: Aluminium_Color, NLRS_A_SACS_SVZ, Belimo_Black
Type - Other - Category: Duct Accessories; Family Name: NLRS_57_DUA_UN_round-firedamper-with-smokesensor-fdc25-ug_sacs
Type - Constraints - Default Elevation: 0 mm
Type - General - Article_Data: FDC25-UG_Article_Data; Selection_Factors: Selection_Factors
Type - Identity Data - Assembly Code: 57.70; Description: Ronde brandklep met rooksensor; Manufacturer: Solid Air Climate Solutions; Model: Brandklep met rooksensor - Rond; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 13-05-2021; NLRS_C_content_provider: Solid Air Climate Systems; NLRS_C_content_versie: Versie 3.19.01; NLRS_C_description: Ronde brandklep met rooksensor; NLRS_C_niveau ontwikkeling: LOD400; Type Comments: Check airflow direction!; Type Name: FDC25 MF1 M24S UG; URL: https://solid-air.nl/producten/brand--en-rookwerende-componenten/brandkleppen
Type - Materials and Finishes - Blade material: Hittebestendig dikte 25mm; Casing material: Gegalvaniseerd plaatstaal; Fuse temperatuur (default): 72 °C
Type - Visibility - Show Symbol: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.70 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: FDC25 MF1 M24S UG; sets with these values: 2
Other - Family: NLRS_57_DUA_UN_round-firedamper-with-smokesensor-fdc25-ug_sacs; Family and Type: NLRS_57_DUA_UN_round-firedamper-with-smokesensor-fdc25-ug_sacs: FDC25 MF1 M24S UG; Type: FDC25 MF1 M24S UG; Type Id: 2431625
Model Properties - Attached Smokesensor (standard): yes; SACS_Air_Velocity: 0 m/s; SACS_Belimo_Rotation (1-3): 1; SACS_Option_1: MF1 = Installatieframe 1; SACS_Option_2: M24S = Belimo 24V; SACS_Option_3: UG = Rooksensor; Sensor_Casing_Rotation: 0
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.018731 m2; NLRS_C_lengte: 681 mm; NLRS_M_c01_diameter: 315 mm; SACS_Duct_Used_Size: 315 mm; Volume: 0.00000420779 m3
Graphics - Use Annotation Scale: no
Identity Data - Mark: 4246; NLRS_C_model: FDC25 MF1 M24S UG 315; SACS_Article_Code: 9250015717; SACS_Gross_Cost: 0; SACS_Price_Date: NB
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; System Classification: Undefined
Mechanical - Flow - NLRS_M_c01_debiet: 0 dm3/s; SACS_Lp_dBA: 4; SACS_Manual_Airflow: 0 dm3/s; SACS_Nominal_Max_Flow: 935.278 dm3/s; SACS_Nominal_Min_Flow: 116.944 dm3/s; SACS_Use_Manual_Airflow: yes
Phasing - Phase Created: New Construction
Visibility - SACS_Disable_Warning: yes; Show_recommended_placement_zone: yes
Insulation - Insulation Thickness: 0 mm
Lining - Lining Thickness: 0 mm
